# Keil uVision project PanelDDS.uvprojx, settings and files
target Panel (6070000::V6.7::.\ARMCLANG)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PanelDDS
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx, KORNET
  c include: .\src;.\src\libs\HAL;.\src\Hardware;..\libs\common;..\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libs/CMSIS
    ./src/libs/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group libs/HAL
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_ll_fmc.h
    ./src/libs/HAL/: stm32f4xx_hal_conf.h
  group src
    ./src/: defines.h main.cpp
    ../libs/common/: Log.cpp Log.h
  group common
    ../Common/: Command.h Command.cpp
  group Display
    ./src/Display/: Display.h Display.cpp DisplayTypes.h InputWindow.h InputWindow.cpp InputWindowStruct.h InputWindowStruct.cpp Symbols.h
    ../libs/common/Display/: Painter.cpp Painter.h Colors.cpp Colors.h PainterText.cpp PainterSTM429.cpp PainterTextSTM429.cpp
  group Display/Font
    ./src/Display/font/: Font.h font5.inc font8.inc fontUGO.inc fontUGO2.inc Font.cpp
  group Generator
    ./src/Generator/: Generator.h Generator.cpp
  group Hardware
    ./src/Hardware/: CPU.cpp CPU.h CPU_FLASH.cpp Timer.cpp Timer.h
    ../libs/common/Hardware/: VCP.cpp VCP.h
  group Hardware/stm32
    ../libs/common/Hardware/stm32/: stm32.cpp stm32.h
    ../libs/common/Hardware/stm32/429/: stm429.cpp stm429.h
  group Keyboard
    ./src/Keyboard/: Keyboard.h Controls.h Keyboard.cpp
  group Menu
    ./src/Menu/: Menu.h MenuItems.h MenuItemsDrawing.h MenuItemsLogic.h Menu.cpp MenuDrawing.cpp MenuItems.cpp MenuItemsDrawing.cpp MenuItemsLogic.cpp
  group Menu/Pages
    ./src/Menu/Pages/: PageSignals.h AddPageInput.h PageDebug.h PageService.h PageSignals2.h
  group Settings
    ./src/Settings/: SettingsTypes.h Settings.h SettingsSignals.h Settings.cpp
  group Utils
    ../libs/common/Utils/: Math.cpp Math.h StringUtils.cpp StringUtils.h
