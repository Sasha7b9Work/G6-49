# Keil uVision project Panel.uvprojx, settings and files
target Panel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PanelDDS
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,PANEL
  c misc: --cpp --diag_suppress=1165
  c include: .\src;.\src\libs\HAL;.\src\Hardware;..\libs\common;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;.\src\libs;..\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Panel.sct
  group libs/CMSIS
    ./src/libs/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group libs/HAL
    ./src/libs/HAL/: stm32f4xx_hal_conf.h
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_ll_fmc.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h
  group src
    ./src/: defines.h log.cpp log.h main.cpp structs.h
  group common
    ../Common/: Command.cpp Command.h
    ../common/: Common.h Common.cpp Message.cpp Message.h Transceiver.h Wave.h
  group Display
    ./src/Display/: Colors.cpp Colors.h Console.cpp Console.h Display.cpp Display.h DisplayTypes.h InputWindow.h InputWindow.cpp InputWindowStruct.cpp Painter.cpp Painter.h PainterSTM429.cpp Symbols.h Text.cpp Text.h Display_429.cpp
  group Display/Font
    ./src/Display/font/: Font.h font5.inc font8.inc Font.cpp
  group FDrive
    ./src/FDrive/: FDrivePanel.cpp FDrivePanel.h File.cpp File_requests.cpp File.h Items.cpp Items.h
  group FrequencyMeter
    ./src/FrequencyMeter/: FrequencyMeter.cpp FrequencyMeter.h
  group Generator
    ./src/Generator/: Wave.cpp WaveGraphics.cpp Signals.cpp Signals.h GeneratorPanel.cpp GeneratorPanel.h
  group Hardware
    ./src/Hardware/: Beeper.h Beeper.cpp Controls.h Controls.cpp CPU.h CPU.cpp CPU_IT.cpp CPU_Keyboard.cpp LTDC.h LTDC.cpp Timer.h Timer.cpp Timer4XX.h Timer4XX.cpp
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL.cpp HAL_DAC2.cpp HAL_SPI4.cpp
  group Hardware/Modules
    ./src/Hardware/Modules/: EEPROM.cpp EEPROM.h
  group Interface
    ./src/Interface/: HandlersPanel.cpp HandlersPanel.h InterfacePanel.cpp InterfacePanel.h Transceiver_429.cpp
  group Menu
    ./src/Menu/: Hint.cpp Hint.h Menu.h Menu.cpp MenuDrawing.cpp MenuItemsGraphics.cpp MenuItems.cpp MenuItems.h MenuItemsLogic.cpp
  group Menu/Pages
    ./src/Menu/Pages/: PageDebug.cpp PageDebug.h PageService.cpp PageService.h PageFrequencyCounter.cpp PageFrequencyCounter.h
  group Menu/Pages/Include
    ./src/Menu/Pages/Include/: PageSignals.h
  group Menu/Pages/Addition
    ./src/Menu/Pages/Addition/: PageInput.cpp PageInput.h PageLoadForm.cpp
  group Menu/Pages/PageSignals
    ./src/Menu/Pages/PageSignals/: PageSignals.cpp PageSignals_Calibration.cpp PageSignals_CalibrationA.cpp PageSignals_CalibrationB.cpp
  group SCPI
    ./src/SCPI/: HeadSCPI.h HeadSCPI.cpp SCPI.h SCPI.cpp VCP.h VCP.cpp
  group Settings
    ./src/Settings/: CalibrationSettings.cpp CalibrationSettings.h Settings.cpp Settings.h SettingsTypes.h
  group Utils
    ./src/Utils/: BigNumber.cpp BigNumber.h CommonFunctions.cpp CommonFunctions.h Debug.cpp Debug.h List.cpp List.h Math.cpp Math.h Number.cpp Number.h NumberBuffer.cpp NumberBuffer.h Queue.cpp Queue.h String.cpp String.h StringUtils.cpp StringUtils.h Statistics.cpp Statistics.h IntValue.cpp IntValue.h Buffer.cpp Buffer.h
