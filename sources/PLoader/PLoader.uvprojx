# Keil uVision project PLoader.uvprojx, settings and files
target PLoader (5060960::V5.06 update 7 (build 960)::.\ARMCC_536_5_06_7)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Panel1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,PLOADER
  c misc: --cpp --diag_suppress=1165
  c include: .\src;.\src\Hardware\HAL;.\src\Hardware;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libs/HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_ll_fmc.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h
  group Hardware
    ./src/Hardware/: CPU.h CPU.cpp Timer.h Timer.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL.cpp HAL_CRC32.cpp HAL_EEPROM.cpp HAL_IT.cpp HAL_LTDC.cpp HAL_PIO.h HAL_PIO.cpp HAL_TIM.cpp HAL_TIM2.cpp HAL_TIM3.cpp HAL_TIM4.cpp stm32f4xx_hal_conf.h
    ../common/Hardware/HAL/: HAL_SPI4_p.cpp
  group src
    ./src/: defines.h structs.h main_pl.cpp Updater_pl.h Updater_pl.cpp
  group common
    ../Common/: Command.h Command.cpp
    ../common/: Common.h Common.cpp Messages_l.cpp Messages_l.h
  group Display
    ./src/Display/: Colors.h Colors.cpp Painter.h Painter.cpp
  group Interface
    ./src/Interface/: Handlers_pl.cpp
    ../common/: Interface_p.cpp Interface_p.h Messages.cpp Messages.h Handlers_p.h
  group Keyboard
    ./src/Keyboard/: Controls.h Keyboard.h Controls.cpp Keyboard.cpp
  group Utils
    ./src/Utils/: Math.h Math.cpp Debug.cpp Debug.h
