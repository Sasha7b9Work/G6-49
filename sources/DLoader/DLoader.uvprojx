# Keil uVision project DLoader.uvprojx, settings and files
target DLoader (5060960::V5.06 update 7 (build 960)::.\ARMCC_536_5_06_7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Device1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, DEBUG, STM32F407xx, LOADER
  c misc: --cpp
  c include: .\src;.\src\Hardware\CMSIS;.\src\Hardware\HAL;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;.\src\Hardware\FatFS;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;.\src\Hardware\USBH;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\src\Hardware\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\sources;..
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libs/HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dma.h stm32f4xx_hal_gpio.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_spi.h stm32f4xx_hal_hcd.h stm32f4xx_ll_usb.h
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group Hardware
    ./src/Hardware/: CPU.cpp CPU.h Timer.cpp Timer.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f407xx.s system_stm32f4xx.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL.cpp HAL_CRC32.cpp HAL_EEPROM.cpp HAL_IT.cpp HAL_PINS.h HAL_PIO.h HAL_PIO.cpp HAL_SPI1.cpp HAL_SPI3.cpp HAL_TIM.cpp HAL_TIM2.cpp HAL_TIM3.cpp stm32f4xx_hal_conf.h
  group src
    ./src/: defines.h main_dl.cpp structs.h Updater_dl.h Updater_dl.cpp
  group common
    ../common/: Common.h Common.cpp
  group Generator
    ./src/Generator/: Generator_d.h
  group Interface
    ./src/Interface/: Handlers_dl.cpp
    ../common/Interface/: Command.cpp Command.h Messages.cpp Messages.h Interface_d.cpp Interface_d.h Messages_l.cpp Messages_l.h Transceiver_d.cpp Transceiver_d.h
  group Settings
    ./src/Settings/: CalibrationSettings.cpp CalibrationSettings.h
  group Utils
    ./src/Utils/: Debug.h Debug.cpp String.cpp String.h Math.cpp Math.h StringUtils.cpp StringUtils.h Buffer.cpp Buffer.h Log.cpp
    ../common/Utils/: Queue.cpp Queue.h
