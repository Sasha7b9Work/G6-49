# Keil uVision project Generator.uvprojx, settings and files
target Generator (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Generator
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, DEBUG, STM32F407xx
  c misc: --cpp
  c include: .\src;.\src\libs\CMSIS;.\src\libs\HAL;..\libs\common;..\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\libs\STM32Cube_F4\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group libs/CMSIS
    ./src/libs/CMSIS/: startup_stm32f407xx.s system_stm32f4xx.c
  group libs/HAL
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_dma.h stm32f4xx_hal_gpio.h stm32f4xx_hal_i2c.h stm32f4xx_hal_rcc.h stm32f4xx_hal_spi.h stm32f4xx_hal_nor.h stm32f4xx_ll_fsmc.h
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_nor.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
    ./src/libs/HAL/: stm32f4xx_hal_conf.h
  group src
    ./src/: main.cpp defines.h Log.cpp Log.h
  group common
    ../Common/: Command.h
  group Generator
    ./src/Generator/: AD9952.cpp AD5697.cpp FPGA.cpp Generator.cpp GeneratorSettings.cpp AD9952.h AD5697.h FPGA.h Generator.h GeneratroSettings.h GeneratorSettingsTypes.h
  group Hardware
    ./src/Hardware/: CPU.cpp CPU.h CPU_IT.cpp stm407.cpp stm407.h stm32.cpp stm32.h Timer.cpp Timer.h VCP.cpp VCP.h Timer4XX.cpp Timer4XX.h
  group Interface
    ./src/Interface/: Interface.cpp Interface.h
