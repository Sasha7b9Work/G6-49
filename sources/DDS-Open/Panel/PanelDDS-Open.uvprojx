# Keil uVision project PanelDDS-Open.uvprojx, settings and files
target Panel-Open (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: PanelDDS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --diag_suppress=161
  c include: .\src;.\src\libs;..\..\Panel\src;..\..\Panel\src\libs\HAL;..\..\Panel\src\Hardware;..\..\common\libs\STM32Cube_F7\Drivers\CMSIS\Include;..\..\common\libs\STM32Cube_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\common\libs\STM32Cube_F7\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6776W
  group HAL
    ./src/libs/: system_stm32f7xx.h
    ../../common/libs/STM32Cube_F7/Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma.h stm32f7xx_hal_cortex.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_ll_fmc.h stm32f7xx_hal_spi.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h
    ../../common/libs/STM32Cube_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_hash.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_cortex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sram.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_sdram.c
  group src
    ../../Panel/src/: defines.h main.cpp globals.cpp Log.cpp Log.h Generator.cpp Generator.h
  group common
    ../../Common/: Command.cpp Command.h
  group Display
    ../../Panel/src/Display/: Display.h Display.cpp DisplayTypes.h InputWindow.h InputWindow.cpp InputWindowStruct.h InputWindowStruct.cpp Symbols.h Painter.cpp Painter.h PainterSTM429.cpp PainterText.cpp Colors.cpp Colors.h PainterTextSTM429.cpp
  group Display/Font
    ../../Panel/src/Display/font/: Font.h font5.inc font8.inc fontUGO.inc fontUGO2.inc Font.cpp
  group Hardware
    ./src/Hardware/: CPU.cpp CPU.h CPU_IT.cpp LTDC.cpp LTDC.h stm32.cpp stm32.h stm746.cpp stm746.h Timer.cpp Timer.h Timer7XX.cpp Timer7XX.h CPU_Keyboard.cpp CPU_FLASH.cpp
  group Menu
    ../../Panel/src/Menu/: Menu.h Menu.cpp MenuDrawing.cpp MenuPagesNames.h MenuItemsAdd.h MenuItemsGraphics.cpp MenuItemsAdd.cpp MenuItemsLogicAdd.cpp MenuItems.cpp MenuItems.h MenuItemsLogic.cpp
  group Menu/Pages
    ../../Panel/src/Menu/Pages/: AddPageInput.cpp PageDebug.cpp PageService.cpp AddPageInput.h PageDebug.h PageService.h PageSettings.cpp PageSettings.h PageSettings2.cpp PageSettings2.h PageFrequencyCounter.cpp PageFrequencyCounter.h
  group Settings
    ../../Panel/src/Settings/: SettingsTypes.h Settings.h SettingsSignals.h Settings.cpp SettingsDisplay.h
  group Utils
    ../../Panel/src/Utils/: Math.cpp Math.h StringUtils.cpp StringUtils.h CommonFunctions.cpp CommonFunctions.h
  group libs
    ./src/libs/: system_stm32f7xx.c startup_stm32f746xx.s stm32f7xx_hal_conf.h system_stm32f7xx.h
