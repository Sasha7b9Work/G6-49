# Keil uVision project PanelDDS.uvprojx, settings and files
target Panel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PanelDDS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --diag_suppress=161
  c include: ..\..\Panel\src;..\..\Panel\src\libs\HAL;..\..\Panel\src\Hardware;..\libs\common;..\..\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\..\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Panel\src\libs
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6776W
  group libs/CMSIS
    ../../Panel/src/libs/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group libs/HAL
    ../../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c
    ../../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_ll_fmc.h
    ../../Panel/src/libs/HAL/: stm32f4xx_hal_conf.h
  group src
    ../../Panel/src/: defines.h main.cpp globals.cpp Log.cpp Log.h Generator.cpp Generator.h
  group common
    ../../Common/: Command.cpp Command.h
  group Display
    ../../Panel/src/Display/: Display.h Display.cpp DisplayTypes.h InputWindow.h InputWindow.cpp InputWindowStruct.h InputWindowStruct.cpp Symbols.h Painter.cpp Painter.h PainterSTM429.cpp PainterText.cpp Colors.cpp Colors.h PainterTextSTM429.cpp
  group Display/Font
    ../../Panel/src/Display/font/: Font.h font5.inc font8.inc fontUGO.inc fontUGO2.inc Font.cpp
  group Hardware
    ../../Panel/src/Hardware/: CPU.cpp CPU_FLASH.cpp CPU_Keyboard.cpp Controls.h CPU.h LTDC.cpp CPU_IT.cpp Timer.cpp Timer.h VCP.cpp VCP.h stm32.cpp stm32.h stm429.cpp stm429.h Timer4XX.cpp Timer4XX.h
  group Menu
    ../../Panel/src/Menu/: Menu.h Menu.cpp MenuDrawing.cpp MenuPagesNames.h MenuItemsAdd.h MenuItemsGraphics.cpp MenuItemsAdd.cpp MenuItemsLogicAdd.cpp MenuItems.cpp MenuItems.h MenuItemsLogic.cpp
  group Menu/Pages
    ../../Panel/src/Menu/Pages/: AddPageInput.cpp PageDebug.cpp PageService.cpp AddPageInput.h PageDebug.h PageService.h PageSettings.cpp PageSettings.h PageSettings2.cpp PageSettings2.h
  group Settings
    ../../Panel/src/Settings/: SettingsTypes.h Settings.h SettingsSignals.h Settings.cpp SettingsDisplay.h
  group Utils
    ../../Panel/src/Utils/: Math.cpp Math.h StringUtils.cpp StringUtils.h
