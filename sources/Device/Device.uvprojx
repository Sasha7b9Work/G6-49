# Keil uVision project Device.uvprojx, settings and files
target Device (5060960::V5.06 update 7 (build 960)::.\ARMCC_536_5_06_7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Device2 +hex
  AfterMake: c:\Keil_v5\ARM\ARMCC_536_5_06_7\bin\fromelf.exe --bin Objects\Device2.axf --output G6-49-D.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, DEBUG, STM32F407xx
  c misc: --cpp
  c include: .\src;.\src\libs\CMSIS;.\src\Hardware\HAL;..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;.\src\Hardware\FatFS;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;.\src\Hardware\USBH;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\src\Hardware\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\sources;..
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device.sct
  group libs/FatFS
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff_gen_drv.h ff.c ff.h diskio.c diskio.h
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
  group libs/HAL
    ./src/libs/HAL/: stm32f4xx_hal_conf.h
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dma.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_nor.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_spi.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_ll_usb.h
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_nor.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
  group libs/USBD
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_ctlreq.h usbd_ioreq.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
  group libs/USBH
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_pipes.h usbh_ctlreq.h usbh_ioreq.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_pipes.c usbh_ctlreq.c usbh_ioreq.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_bot.h usbh_msc_scsi.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Hardware
    ./src/Hardware/: CPU.cpp CPU.h Timer.cpp Timer.h VCP_d.cpp VCP_d.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f407xx.s system_stm32f4xx.c
  group Hardware/FatFS
    ./src/Hardware/FatFS/: FatFS.cpp FatFS.h ffconf.h
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL.cpp HAL_CRC32.cpp HAL_EEPROM.cpp HAL_HCD.cpp HAL_I2C1.cpp HAL_IT.cpp HAL_PCD.cpp HAL_PINS.h HAL_PIO.h HAL_PIO.cpp HAL_SPI1.cpp HAL_SPI3.cpp HAL_TIM.cpp HAL_TIM2.cpp HAL_TIM3.cpp stm32f4xx_hal_conf.h
  group Hardware/USBD
    ./src/Hardware/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_core.cpp usbd_desc.cpp usbd_desc.h
  group Hardware/USBH
    ./src/Hardware/USBH/: usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h
  group src
    ./src/: defines.h structs.h main_d.cpp Log.cpp Log.h
    ../Common/: defines_com.h
  group common
    ../Common/: Command.h Command.cpp
    ../common/: Common.h Common.cpp Handlers_d.h Interface_d.h Interface_d.cpp Messages.h Messages.cpp Transceiver.h Transceiver_d.cpp
  group FDrive
    ./src/FDrive/: FDrive_d.h FDrive_d.cpp FDrive_d_Handler.cpp
  group FreqMeter
    ./src/FreqMeter/: FreqMeter_d.h FreqMeter_d.cpp
  group Generator
    ./src/Generator/: AD5697.h AD5697.cpp AD9952.h AD9952.cpp Generator_d.h Generator_d.cpp Calibrator.cpp Calibrator.h Filtr.cpp Filtr.h
  group Generator/FPGA
    ./src/Generator/FPGA/: FPGA.cpp FPGA.h RegistersFPGA.cpp RegistersFPGA.h Clock.cpp Clock.h ParametersFPGA.cpp ParametersFPGA.h
  group Interface
    ./src/Interface/: Handlers_d.cpp
  group Settings
    ./src/Settings/: CalibrationSettings.cpp CalibrationSettings.h
  group Utils
    ./src/Utils/: Buffer.cpp Buffer.h Debug.cpp Debug.h Math.h Math.cpp Memory.cpp Memory.h Queue.cpp Queue.h String.cpp String.h StringUtils.cpp StringUtils.h
